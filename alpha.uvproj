# Keil uVision project alpha.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2148 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: alpha +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s pwm.c pwm.h Std_Types.h Platform_Types.h Pwm_PbCfg.c Pwm_Reg.h Pwm_Types.h Pwm_Reg.c Mcu.c main.c Port.c
